options:
  parameters:
    generate_options: qt_gui
    id: ModulacionPAM_3signals
    output_language: python
    title: ModulacionPAM_3signals
  states: {}

blocks:
- name: d1
  id: variable_qtgui_range
  parameters:
    label: square
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: d2
  id: variable_qtgui_range
  parameters:
    label: triangle
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: d3
  id: variable_qtgui_range
  parameters:
    label: saw tooth
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '30'
  states: {}
- name: d4
  id: variable_qtgui_range
  parameters:
    label: demodulador
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: fm
  id: variable
  parameters:
    value: fs/10
  states: {}
- name: fs
  id: variable
  parameters:
    value: samp_rate/100
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: w
  id: variable_qtgui_range
  parameters:
    label: ancho de pulso
    rangeType: int
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_3
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: d2
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: d1
    type: float
  states: {}
- name: blocks_delay_2
  id: blocks_delay
  parameters:
    delay: d3
    type: float
  states: {}
- name: blocks_delay_3
  id: blocks_delay
  parameters:
    delay: d4
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: modulacionPAM_0
  id: modulacionPAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: modulacionPAM_0_0
  id: modulacionPAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: modulacionPAM_0_0_0
  id: modulacionPAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: modulacionPAM_0_0_0_0
  id: modulacionPAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: modulacionPAM_4
  id: modulacionPAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_1, '0', modulacionPAM_0_0, '0']
- [analog_sig_source_x_2, '0', modulacionPAM_0_0_0, '0']
- [analog_sig_source_x_3, '0', modulacionPAM_0_0_0_0, '0']
- [blocks_add_xx_0, '0', blocks_delay_3, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '2']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_1, '0', blocks_add_xx_0, '1']
- [blocks_delay_1, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_2, '0', blocks_add_xx_0, '3']
- [blocks_delay_2, '0', qtgui_time_sink_x_0, '3']
- [blocks_delay_3, '0', modulacionPAM_4, '0']
- [blocks_throttle_0, '0', modulacionPAM_0, '0']
- [modulacionPAM_0, '0', blocks_add_xx_0, '0']
- [modulacionPAM_0, '0', qtgui_time_sink_x_0, '0']
- [modulacionPAM_0_0, '0', blocks_delay_1, '0']
- [modulacionPAM_0_0_0, '0', blocks_delay_0, '0']
- [modulacionPAM_0_0_0_0, '0', blocks_delay_2, '0']
- [modulacionPAM_4, '0', qtgui_time_sink_x_1, '1']

metadata:
  file_format: 1
